Commit message: ym

File: src/lidar_rviz/urdf/myfirst.urdf (robot description, URDF)
Before this commit: robot test_sensor, 5 links, 4 joints
Joints:
- removed joint tf_scan_joint
- added joint parser_joint: type fixed, parent base_link, child tf_scan, origin xyz=0 0 0 rpy=0 0 0
